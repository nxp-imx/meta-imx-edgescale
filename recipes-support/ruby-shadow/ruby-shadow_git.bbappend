# Ruby was upgraded to 2.5.0 in sumo.
# A upgrade in the ruby-shadow is needed to build

PV = "2.5.0"

SRCREV = "d2e822d8a8bda61f0774debbfce363a7347ed893"
